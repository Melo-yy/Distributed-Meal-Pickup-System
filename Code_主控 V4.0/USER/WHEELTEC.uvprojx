# Keil uVision project WHEELTEC.uvprojx, settings and files
target FreeRTOS (5060528::V5.06 update 5 (build 528)::.\ARMCC)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.0
  cpu: IROM(0x08008000,0x38000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: WHEELTEC +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,__FPU_PRESENT=1,__TARGET_FPU_VFP,ARM_MATH_CM4,__CC_ARM
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\LED;..\FWLIB\inc;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\BALANCE;..\HARDWARE;..\BSP;..\APP;..\FlashDB;..\FlashDB\inc;..\U8G2
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c main.h stm32f4xx_it.c system_stm32f4xx.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_tim.c stm32f4xx_pwr.c stm32f4xx_flash.c
  group FreeRTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
  group BSP
    ../BSP/: bsp_led.c bsp_led.h bsp_delay.c bsp_delay.h bsp_usart.c bsp_usart.h bsp_sys.c bsp_sys.h bsp_scan.c bsp_scan.h bsp_can.c bsp_can.h bsp_voice.c bsp_voice.h bsp_show.c bsp_show.h bsp_4g.c bsp_4g.h
  group APP
    ../APP/: app_show.c app_show.h app_led.c app_led.h app_system.c app_system.h app_can.c app_can.h app_can_common.h app_scan.c app_scan.h app_voice.c app_voice.h FlashDB_test.c FlashDB_test.h app_4g.c app_4g.h debug_config.h app_ota.c ota_meta.h
  group FlashDB
    ../FlashDB/: fal.c fal_flash.c fal_flash_stm32f4.c fal_partition.c fdb.c fdb_kvdb.c fdb_tsdb.c fdb_utils.c
