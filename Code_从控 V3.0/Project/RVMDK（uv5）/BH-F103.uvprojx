# Keil uVision project BH-F103.uvprojx, settings and files
target USART (5060528::V5.06 update 5 (build 528)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: USART +hex
  c flags: Optim=1 uC99=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\User\usart;..\..\Hardware;..\..\FWLB;..\..\freerots\Inc;..\..\freerots\port;..\..\freerots\src;..\..\freerots;..\..\System;..\..\APP;..\..\BSP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h main.h
    ../../User/delay/: delay.c
  group Sys
    ../../System/: usart.c usart.h
  group APP
    ../../APP/: app_show.c app_show.h app_led.c app_led.h app_system.c app_system.h app_can.c app_can.h app_can_common.h app_scan.c app_scan.h app_voice.c app_voice.h debug_config.h
  group BSP
    ../../BSP/: bsp_show.c bsp_show.h bsp_led.c bsp_led.h bsp_sys.c bsp_sys.h bsp_can.c bsp_can.h bsp_scan.c bsp_scan.h bsp_voice.c bsp_voice.h
  group Hardware
    ../../Hardware/: LED.c LED.h Key.c Key.h OLED.c OLED.h OLED_Font.h
  group freertos/Inc
    ../../freerots/: FreeRTOSConfig.h
    ../../freerots/Inc/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
  group freertos/src
    ../../freerots/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group freertos/port
    ../../freerots/port/: heap_4.c port.c
